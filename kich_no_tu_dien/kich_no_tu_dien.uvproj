# Keil uVision project kich_no_tu_dien.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: kich_no_tu_dien +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: kich_no_tu_dien.c
    ../library/: delay.c
