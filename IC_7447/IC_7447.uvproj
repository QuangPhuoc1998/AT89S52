# Keil uVision project IC_7447.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: IC_7447 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: IC_7447.c
    ../library/: delay.c
