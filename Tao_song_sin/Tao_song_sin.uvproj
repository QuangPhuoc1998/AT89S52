# Keil uVision project Tao_song_sin.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Tao_song_sin +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Tao_song_sin.c
    ../library/: delay.c
