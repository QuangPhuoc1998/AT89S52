# Keil uVision project code.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: main.c main.h delay.c delay.h
