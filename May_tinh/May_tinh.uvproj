# Keil uVision project May_tinh.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: May_tinh +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: May_tinh.c
    ../library/: delay.c
