# Keil uVision project Dieu_khien_thiet_bi.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: Dieu_khien_thiet_bi +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: delay.c delay.h LCD4.c LCD4.h main.c main.h UartMode1.c UartMode1.h
